* Title : RLC

* Netlist
V1 a 0 pulse(0 5 0.1m 0.1m 0.1m 1m 2m)
R1 a b 1
L1 b c 1mH
C1 c 0 100uF
R2 c 0 1k

* Control Commands
.control
    tran 1us 10ms uic
    run
    plot v(a) v(b) v(c)
.endc
